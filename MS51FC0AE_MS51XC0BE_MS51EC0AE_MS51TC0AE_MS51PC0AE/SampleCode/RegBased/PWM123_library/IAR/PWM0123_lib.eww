<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PWM0123_lib.ewp</path>
    </project>
    <batchBuild />
</workspace>
